# Repository DL7AD/pecanpico8

## KiCad design hardware/pecanpico8.kicad_pcb

Parts:
C1, C22, C31, C50: 22u; C_0805
C2: 1n; C_0402
C3, C4, C6: 10u; C_0805
C5: 22pF; C_0402
C7, C8, C9, C10, C11, C12, C13, C35, C36, C37, C39, C40, C41, C42, C49: 2u2; C_0402
C14, C17, C20, C21, C23, C29, C30, C33, C43, C44, C45, C46, C47, C48: 100n; C_0402
C15, C16, C34: 100p; C_0402
C18, C19, C25, C27: 470p; C_0402
C24, C26: 22p; C_0402
C28: 1u; C_0402
C32: 10nF; C_0402
C38: 10n; C_0402
D1: yellow; LED_0603
D2: blue; LED_0603
D3: green; LED_0603
D4, D7, D10: red; LED_0603
D8, D9: RFN1L7STE25; MELF_Standard; Mouser 755-RFN1L7STE25
F1: PMS1206-075; Fuse_SMD1206_Reflow; Mouser 637-PMS1206-075
IC1: SPV1040T; TSSOP-8_4.4x3mm_Pitch0.65mm; Mouser 511-SPV1040T
IC2: TPS62260DRVR; DFN-6-1EP_2x2mm_Pitch0.65mm; Mouser 595-TPS62260DRVR
IC3: ADP322ACPZ-115-R7; QFN-16-1EP_3x3mm_Pitch0.5mm; Mouser 584-ADP322ACPZ-115R7
IC4: Si4063-B1B-FM; QFN-20-1EP_4x4mm_Pitch0.5mm; Mouser 634-SI4063-B1B-FM
IC5: STM32F429IIH6; UFBGA176; Mouser 511-STM32F429IIH6
IC6: EVA-7M; EVA7M
IC7: PAC1720-1-AIA-TR; DFN-10-1EP_3x3mm_Pitch0.5mm; Mouser 579-PAC1720-1-AIA-TR
IC8: LDLN015PU33R; DFN-6-1EP_2x2mm_Pitch0.5mm; Mouser 511-LDLN015PU33R
IC9: BME280; Mouser 262-BME280
L1: XAL4040-103; XAL4040; Mouser 994-XAL4040-103MEC
L2: LPS3015-222; LPS3015; Mouser 994-LPS3015-222MRC
L3: 470nH; C_0805; Mouser 994-0805LS-471XJLB
L4, L6: 56n; C_0805; Mouser 994-0805CS-560XJLC
L5: 82n; C_0805; Mouser 994-0805CS-820XJLC
P1: CONN_02X13; OV2640_Header
P2: CONN_01X11; Pin_Header_Straight_1x11
P3: ZX62-B-5PA(33); USB_Micro-B_SMD; Mouser 798-ZX62-B-5PA33
P4, P6: IPX 2mm; IPX_2mm; Mouser 960-RECE20279001E01
P5: CONN_01X02; Pin_Header_Straight_1x02_SMD
P7: CONN_02X13; OV2640_Socket
Q1: FDN306P; SOT-23; Mouser 512-FDN306P
R1: 220k; R_0402
R2, R14, R17, R23, R24, R28, R31: 100k; R_0402
R3, R5, R33: 22k; R_0402
R4, R6, R32: 10k; R_0402
R7: 500k; R_0402
R8, R36: 250k; R_0402
R9, R10, R11, R12, R21, R35: 1k5; R_0402
R13, R19, R20: N/A; R_0402
R18, R22: 0R1; R_0603; Mouser 71-WSLP0603R1000FEA
R25, R26: 4k7; R_0402
R27: 0R; R_0402
R29, R30, R34: 1k; R_0402
U3: uctronics OV2640; OV2640
W1: Testpad; PAD_3x1.5
W6, W8, W10, W11: Pad; PAD_6x3
W7: Pad; PAD_3x3
W12, W13, W14, W15, W16, W17, W18, W19, W20, W21, W22, W23, W24, W26, W27: Testpad
X1: KT2016K26000BCW18ZAS; tcxo; Mouser 581-KT2016K2BCW18ZAS

Connections:
+1V8: C5.1, C6.1, C13.1, C14.1, C15.1, C17.1, C18.1, C23.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, IC4.6 (VBATA), IC4.8 (VBATD), IC5.C1 (VBAT), IC5.C5 (VDD), IC5.C6 (PDR_ON), IC5.C7 (VDD), IC5.C8 (VDD), IC5.C9 (VDD), IC5.F3 (VDD), IC5.G3 (VDD), IC5.G13 (VDD), IC5.H13 (VDDUSB), IC5.J12 (VDD), IC5.J13 (VDD), IC5.K4 (VDD), IC5.N8 (VDD), IC5.N9 (VDD), IC5.N10 (VDD), IC5.P1 (VREF+), IC5.R1 (VDDA), IC6.21 (VCC_BCKP), IC9.2 (CSB), IC9.5 (SDO), IC9.6 (VDDIO), IC9.8 (VDD), L2.2, L3.2, P1.3, P5.2, P7.3, R7.1, R17.2, R23.1, R25.1, R26.1, R27.1, R35.1
+1V35: C12.1, C30.2, IC3.8 (VOUT3), P1.7, P1.9, W23.1
+3V3: C10.1, IC3.5 (VOUT1), IC7.10 (VDD), R9.1, R10.1, R11.1, R12.1, W21.1
+BATT: IC7.3 (SENSE2+), P2.11, R22.1, R29.2
+OSC: C48.1, C49.1, IC5.L14 (FMC_D1/FMC_DA1/TIM4_CH4/UART8_RTS/PD15), IC5.M14 (FMC_D0/FMC_DA0/TIM4_CH3/UART8_CTS/PD14), IC5.M15 (FMC_A18/I2C4_SDA/LPTIM1_OUT/QUADSPI_BK1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), R27.2, X1.4 (VCC)
+SOL: C1.1, F1.2, IC1.1 (VINSNS), IC1.8 (XSHUNT), IC7.1 (SENSE1+), L1.2, P2.9, R3.1, R18.1, R28.1, W7.1
/ADC_VBAT: IC5.P5 (ADC1_IN15/ADC2_IN15/ETH_RXD1/FMC_SDCKE0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), R5.2, R6.1
/ADC_VSOL: IC5.R2 (ADC1_IN3/ADC2_IN3/ADC3_IN3/ETH_COL/TIM2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), R3.2, R4.1
/ADC_VUSB: IC5.R3 (ADC1_IN7/ADC2_IN7/ETH_CRS_DV/ETH_RX_DV/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), R32.1, R33.2
/BATT_CONN: P2.10, W11.1
/BOOT0: IC5.D6 (BOOT0), P5.1, R31.1
/CAM_D2: IC5.H15 (DCMI_D0/I2S2_MCK/SDMMC1_D6/TIM3_CH1/TIM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), P1.19
/CAM_D3: IC5.G15 (DCMI_D1/I2S3_MCK/SDMMC1_D7/TIM3_CH2/TIM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), P1.24
/CAM_D4: IC5.G14 (DCMI_D2/SDMMC1_D0/SYS_TRACED1/TIM3_CH3/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), P1.23
/CAM_D5: IC5.F14 (DAC_EXTI9/DCMI_D3/I2C3_SDA/I2S_CKIN/QUA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), P1.22
/CAM_D6: IC5.B1 (DCMI_D4/FMC_A20/SAI1_FS_A/SPI4_NSS/SYS_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), P1.4
/CAM_D7: IC5.B6 (CAN2_TX/CEC/DCMI_D5/FMC_SDNE1/I2C1_SCL/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), P1.17
/CAM_D8: IC5.B2 (DCMI_D6/FMC_A21/SAI1_SCK_A/SPI4_MISO/SY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), P1.10
/CAM_D9: IC5.B3 (DCMI_D7/FMC_A22/SAI1_SD_A/SAI2_MCLK_B/S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), P1.18
/CAM_EN: IC3.15 (EN3), IC3.16 (EN2), IC5.K1 (PF7/ADC3_IN5/QUADSPI_BK1_IO2/SAI1_MCLK_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), R14.1
/CAM_GPIO0: IC5.A4 (DCMI_D2/FMC_NBL0/LPTIM1_ETR/SAI2_MCLK_A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), P1.15
/CAM_GPIO1: IC5.A3 (DCMI_D3/FMC_NBL1/LPTIM1_IN2/UART8_TX/PE1), P1.13
/CAM_GPIO2: IC5.A2 (ETH_TXD3/FMC_A23/QUADSPI_BK1_IO2/SAI1_M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), P1.8
/CAM_HREF: IC5.N4 (ADC1_IN4/ADC2_IN4/DAC_OUT1/DCMI_HSYNC/I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), P1.11
/CAM_PCLK: IC5.P3 (ADC1_IN6/ADC2_IN6/DCMI_PIXCLK/SPI1_MISO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), P1.20
/CAM_RESET: IC5.A1 (FMC_A19/SAI1_SD_B/SYS_TRACED0/PE3), P1.6
/CAM_VSYNC: IC5.B5 (DCMI_VSYNC/FMC_NL/I2C1_SDA/TIM4_CH2/USA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), P1.16
/CAM_XCLK: IC5.F15 (I2C3_SCL/RCC_MCO_1/TIM1_CH1/TIM8_BKIN2/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), P1.21
/CLOCK_26M: C16.1, C32.1, X1.3 (FREQ)
/CLOCK_CTRL: IC5.P4 (ADC1_IN5/ADC2_IN5/DAC_OUT2/I2S1_CK/SPI1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), R23.2, R24.1, W24.1, X1.1 (AFC)
/GPS_EN: IC5.B14 (DCMI_D8/I2S3_CK/QUADSPI_BK1_IO1/SDMMC1_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), IC8.3 (EN)
/GPS_IRQ: IC5.B15 (CAN1_TX/SAI2_FS_B/TIM1_ETR/USART1_RTS/U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), IC6.13 (EXTINT), W20.1
/GPS_RESET: IC5.A9 (I2S2_WS/SPI1_MISO/SPI2_NSS/SPI3_MISO/SY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), IC6.14 (RESET), W19.1
/GPS_RXD: IC5.D12 (DCMI_D11/SDMMC1_CMD/SYS_TRACED2/TIM3_ET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), IC6.16 (TX_MISO), W15.1
/GPS_TIMEPULSE: IC5.A11 (FMC_NE1/SPDIFRX_IN0/USART2_CK/PD7), IC6.31 (TIMEPULSE), R21.2
/GPS_TXD: IC5.A12 (DCMI_D9/I2S3_SD/SDMMC1_CK/SPI3_MOSI/SYS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), IC6.15 (RX_MOSI), W17.1
/I2C_SCL: IC5.A5 (CAN1_RX/DCMI_D6/ETH_TXD3/I2C1_SCL/SDMMC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), IC7.9 (SMCLK), P1.14, R19.1, R25.2, W26.1
/I2C_SDA: IC5.B4 (CAN1_TX/DAC_EXTI9/DCMI_D7/I2C1_SDA/I2S2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), IC7.8 (SMDATA), P1.12, R20.1, R26.2, W27.1
/IO_LED1: D1.1 (K), IC5.R4 (ADC1_IN9/ADC2_IN9/ETH_RXD3/TIM1_CH3N/TI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)
/IO_LED2: D2.1 (K), IC5.R5 (ADC1_IN8/ADC2_IN8/ETH_RXD2/TIM1_CH2N/TI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)
/IO_LED3: D3.1 (K), IC5.P8 (FMC_D5/FMC_DA5/QUADSPI_BK2_IO1/TIM1_CH1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)
/IO_LED4: D4.1 (K), IC5.P11 (FMC_D11/FMC_DA11/SAI2_MCLK_B/SPI4_MOSI/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)
/IO_RXD: IC5.R13 (ADC1_EXTI11/ADC2_EXTI11/ADC3_EXTI11/ETH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), P2.7
/IO_TXD: IC5.R12 (ETH_RX_ER/I2C2_SCL/I2S2_CK/SPI2_SCK/TIM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), P2.6
/OV2640_AVDD: C21.1, P7.5, R34.1, U3.17 (AVDD)
/OV2640_D2: P7.19, U3.2 (Y2)
/OV2640_D3: P7.24, U3.19 (Y3)
/OV2640_D4: P7.23, U3.13 (Y4)
/OV2640_D5: P7.22, U3.23 (Y5)
/OV2640_D6: P7.4, U3.3 (Y6)
/OV2640_D7: P7.17, U3.24 (Y7)
/OV2640_D8: P7.10, U3.4 (Y8)
/OV2640_D9: P7.18, U3.1 (Y9)
/OV2640_DOVDD: P7.9, U3.22 (DOVDD)
/OV2640_DVDD: P7.7, U3.20 (DVDD)
/OV2640_HREF: P7.11, U3.10 (HREF)
/OV2640_PCLK: P7.20, U3.21 (PCLK)
/OV2640_PWDN: P7.8, U3.9 (PWDN)
/OV2640_RESET: P7.6, U3.7 (RESET)
/OV2640_SCL: IC9.4 (SCK), P7.14, U3.14 (SIO_C)
/OV2640_SDA: IC9.3 (SDI), P7.12, U3.15 (SIO_D)
/OV2640_VSYNC: P7.16, U3.12 (VSYNC)
/OV2640_XCLK: P7.21, U3.5 (XCLK)
/RADIO_CS: IC4.15 (CS), IC5.D15 (DCMI_D1/TIM1_CH3/USART1_RX/USB_OTG_FS_I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), W12.1
/RADIO_GPIO0: IC4.9 (GPIO0), IC5.N14 (ADC1_EXTI11/ADC2_EXTI11/ADC3_EXTI11/FMC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)
/RADIO_GPIO1: IC4.10 (GPIO1), IC5.P15 (FMC_D13/FMC_DA13/SPDIFRX_IN1/USART3_TX/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)
/RADIO_IRQ: IC4.11 (IRQ), IC5.N15 (FMC_D15/FMC_DA15/USART3_CK/PD10), W18.1
/RADIO_SDN: IC4.1 (SDN), IC5.P14 (DAC_EXTI9/FMC_D14/FMC_DA14/USART3_RX/PD9), R17.1
/SENSE_SOL-: IC7.2 (SENSE1-), Q1.3 (S), R18.2
/SOL_SHORT_EN: IC5.R9 (FMC_D7/FMC_DA7/QUADSPI_BK2_IO3/TIM1_CH2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), Q1.1 (G), R13.1, R28.2
/SPI_MISO: IC4.13 (SDO), IC5.C14 (PI2/DCMI_D9/FMC_D26/SPI2_MISO/TIM8_CH4), W14.1
/SPI_MOSI: IC4.14 (SDI), IC5.C13 (PI3/DCMI_D10/FMC_D27/I2S2_SD/SPI2_MOSI/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), W13.1
/SPI_SCK: IC4.12 (SCK), IC5.D14 (PI1/DCMI_D8/FMC_D25/I2S2_CK/SPI2_SCK/TI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), W16.1
/SWD_NRST: IC5.J1 (NRST), P2.4
/SWD_SWCLK: IC5.A14 (SYS_JTCK-SWCLK/PA14), P2.1
/SWD_SWDIO: IC5.A15 (SYS_JTMS-SWDIO/PA13), P2.3
/SWD_SWO: IC5.A10 (I2S1_CK/I2S3_CK/SPI1_SCK/SPI3_SCK/SYS_J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), P2.5
/USB_D+: IC5.R15 (I2S2_SD/RTC_REFIN/SPI2_MOSI/TIM12_CH2/T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), P3.3 (D+), R35.2
/USB_D-: IC5.R14 (SPI2_MISO/TIM12_CH1/TIM1_CH2N/TIM8_CH2N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), P3.2 (D-)
/USB_VUSB: D9.2 (A), IC5.P13 (CAN2_TX/ETH_TXD1/I2S2_CK/SPI2_SCK/TIM1_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), P3.1 (VCC), R33.1
/VCC_GPS: C20.1, C22.1, D7.2 (A), IC6.19 (VCC), IC6.20 (VCC_IO), IC8.6 (OUT)
/V_BOOST: IC5.R6 (PF11/ADC1_EXTI11/ADC2_EXTI11/ADC3_EXTI1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), P3.4 (ID), R36.2
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C26.2, C29.2, C30.1, C31.1, C33.1, C34.1, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, IC1.2 (GND), IC2.2 (MODE), IC2.6 (GND), IC2.7 (THERM), IC3.12 (GND), IC3.17 (GND), IC4.18 (GND), IC4.21 (THERMAL), IC5.D5 (VSS), IC5.D7 (VSS), IC5.D8 (VSS), IC5.D9 (VSS), IC5.F2 (VSS), IC5.F6 (VSS), IC5.F7 (VSS), IC5.F8 (VSS), IC5.F9 (VSS), IC5.F10 (VSS), IC5.F12 (VSS), IC5.G2 (VSS), IC5.G6 (VSS), IC5.G7 (VSS), IC5.G8 (VSS), IC5.G9 (VSS), IC5.G10 (VSS), IC5.G12 (VSS), IC5.H6 (VSS), IC5.H7 (VSS), IC5.H8 (VSS), IC5.H9 (VSS), IC5.H10 (VSS), IC5.H12 (VSS), IC5.J6 (VSS), IC5.J7 (VSS), IC5.J8 (VSS), IC5.J9 (VSS), IC5.J10 (VSS)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
unnamed: C2.1, IC1.5 (VCTRL), R1.2, R2.1
unnamed: C5.2, IC2.3 (FB), R7.2, R8.1, R36.1
unnamed: C16.2, IC4.17 (XIN)
unnamed: C19.1, L4.2
unnamed: C19.2, IC4.4 (TX), L3.1
unnamed: C24.1, C25.1, L4.1, L5.2
unnamed: C25.2, C26.1, C27.1, L5.1, L6.2
unnamed: C27.2, L6.1, P4.1, W1.1
unnamed: C28.1, IC1.6 (ICTRL-), R29.1
unnamed: C28.2, IC1.7 (ICTRL+), R30.1
unnamed: C32.2, IC5.G1 (PH0/RCC_OSC_IN)
unnamed: C35.1, IC5.F13 (VCAP_2)
unnamed: C36.1, IC5.M10 (VCAP_1)
unnamed: D1.2 (A), R9.2
unnamed: D2.2 (A), R10.2
unnamed: D3.2 (A), R11.2
unnamed: D4.2 (A), R12.2
unnamed: D7.1 (K), R21.1
unnamed: D8.1 (K), F1.1
unnamed: D8.2 (A), D9.1 (K)
unnamed: D10.1 (K), P7.15
unnamed: D10.2 (A), R34.2
unnamed: IC1.3 (LX), L1.1
unnamed: IC2.1 (SW), L2.1
unnamed: IC6.1 (RF_IN), P6.1
unnamed: IC6.29 (SCL_SCK), R19.2
unnamed: IC6.30 (SDA_CS), R20.2
unnamed: W6.1, W8.1
VDD: C3.1, C4.1, C7.1, C8.1, C9.1, C29.1, C50.1, IC1.4 (VOUT), IC2.4 (EN), IC2.5 (VIN), IC3.1 (EN1), IC3.2 (VBIAS), IC3.3 (VIN1/VIN2), IC3.10 (VIN3), IC7.4 (SENSE2-), IC8.1 (IN), R1.1, R5.1, R22.2, R30.2
VDDA: C11.1, C31.2, C33.2, C34.2, IC3.6 (VOUT2), P1.5, W22.1

Notes on the sheet:
USB only work with USB hosts like computer. The USB ID pin used to switch VCC from 1.8V to 3.3V USB Slaves like USB Sticks do not work, because USB ID pin is not connected to STM32.
Clock CTRL may be used to modulate the Si4464. It may also influence the clock of the STM32 but only slightly.
Voltage can be measured by IC7
Duplicate BME280 on the camera daughter board. IC9 may be used instead of IC8 because it is more far away from heat sources. It may measure the temperature and humidity more accurately. Note: IC8 and IC9 have different addresses.
V_BOOST is pulled down by STM32 or by USB Host. When V_BOOST is pulled down the TPS62260 will switch to 3.0V. This is necessary for USB commu- nication and to get more power out of the Si4464. V_BOOST must not be pulled high because the TPS62260 will fail.
ADP controls the supply voltage for the camera and the GPS. Both need a clean voltage.
Put jumper on Pins 10 and 11 in order to connect the battery to the actual circuit. So you don't have to desolder the battery everytime.
Battery
Solar
Debug
Programming
Battery connection pads
Solar left-to-right interconnection
Solar cells must be connected to pad W7 and W10.
The battery can be charged by USB. The USB supply is not connected directly to the SPV1040 while the input voltage must not exceed by 4.1V.
Camera edge connector and daugther board (camera + additional BME280)
2m Transceiver
Power
GPS
Connectors
+BATT Directly connected to battery +SOL Solar network VDD Connected to battery through sense resistor +1V8 Main power supply for STM32 and transmitter +3V3 LED and PAC1720 power supply +VDDA Analog power supply for camera +1V35 Core power supply for camery (actually 1.8V)
If SOL_SHORT_EN is enabled, the current of the solar cell can be measured by the PAC1720

Board: 4 copper layers, 29.8 x 44.7 mm, 139 parts (28 on the bottom side), 113 nets.

Notices in the files:
software/board/board.h:
ChibiOS - Copyright (C) 2006..2015 Giovanni Di Sirio
Licensed under the Apache License, Version 2.0 (the "License");
