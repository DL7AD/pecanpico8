# Repository DL7AD/pecanpico8 (continued)

## KiCad design pecanpico8.kicad_pcb

Parts:
C1, C22, C31: 22u; C_0805
C2: 1n; C_0402
C3, C4, C6: 10u; C_0805
C5: 22pF; C_0402
C7, C8, C9, C10, C11, C12, C13, C35, C36, C37, C39, C40, C41, C42, C49: 2u2; C_0402
C14, C20, C23, C29, C30, C33, C43, C44, C45, C46, C47, C48: 100n; C_0402
C15, C16, C34: 100p; C_0402
C17: NA; C_0402
C18, C19, C50, C51: 470p; C_0402
C21: 18p; C_0402
C24: 4p7; C_0402
C25, C27: 22p; C_0402
C26: 1p8; C_0402
C28: ?; C_0402
C32: 10nF; C_0402
C38: 10n; C_0402
D1, D2, D3, D4, D6: green; LED_0603
D5, D7, D10: red; LED_0603
D8, D9: DIODE; MELF_Standard
D11: yellow; LED_0603
F1: 500mA; Fuse_SMD1206_Reflow
IC1: SPV1040; TSSOP-8_4.4x3mm_Pitch0.65mm
IC2: TPS62260; DFN-6-1EP_2x2mm_Pitch0.65mm
IC3: ADP322ACPZ-115-R7; QFN-16-1EP_3x3mm_Pitch0.5mm
IC4: Si4464; QFN-20-1EP_4x4mm_Pitch0.5mm
IC5: STM32F745IGKx; UFBGA176
IC6: EVA-7M; EVA7M
IC7: PAC1720; DFN-10-1EP_3x3mm_Pitch0.5mm
IC8: BME280
L1: 10u; LPS3015
L2: 2u2; LPS3015
L3: 470nH; R_0603
L4: 56n; R_0603
L5, L6: 68n; R_0603
L7: 56n; R_0402
P1: CONN_01X25; FFC1x24_0.5mm
P2: CONN_01X11; Pin_Header_Straight_1x11
P3: USB_OTG; USB_Mini-B
P4: SMA Edge; SMA_EDGE
P5: CONN_01X02; Pin_Header_Straight_1x02_SMD
Q1: FDN306P; SOT-23
R1, R3, R5, R33: 22k; R_0402
R2, R4, R6, R32: 10k; R_0402
R7: 500k; R_0402
R8, R36: 250k; R_0402
R9, R10, R11, R12, R19, R20: 0R; R_0402
R13, R14, R17, R23, R24, R28: 100k; R_0402
R15, R21, R35: 1k5; R_0402
R16: 330R; R_0402
R18, R22: 0R1; R_0603
R25, R26: 4k7; R_0402
R27, R31: NA; R_0402
R29, R30: ?; R_0402
R34: 1k5; R_0603
R37: 330R; R_0603
W1: TEST; R_0402
W2, W5: Pad; PAD_6x1.5
W3: Pad; PAD_3x1.5
W4: Pad; PAD_4x4
W6, W8, W10, W11: Pad; PAD_6x3
W7: Pad; PAD_3x3
W12, W13, W14, W15, W16, W17, W18, W19, W20, W21, W22, W23, W24, W26, W27: Testpad; Measurement_Point_Round-SMD-Pad_Small
W25: Pad; Measurement_Point_Round-SMD-Pad_Small
X1: KT2016K26000BCW18ZAS; tcxo

Connections:
+1V8: C5.1, C6.1, C13.1, C14.1, C15.1, C18.1, C23.1, C29.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, IC4.6 (VBATA), IC4.8 (VBATD), IC5.C1 (VBAT), IC5.C5 (VDD), IC5.C6 (PDR_ON), IC5.C7 (VDD), IC5.C8 (VDD), IC5.C9 (VDD), IC5.F3 (VDD), IC5.G3 (VDD), IC5.G13 (VDD), IC5.H13 (VDDUSB), IC5.J12 (VDD), IC5.J13 (VDD), IC5.K4 (VDD), IC5.N8 (VDD), IC5.N9 (VDD), IC5.N10 (VDD), IC5.P1 (VREF+), IC5.R1 (VDDA), IC6.20 (VCC_IO), IC6.21 (VCC_BCKP), IC8.2 (CSB), IC8.5 (SDO), IC8.6 (VDDIO), IC8.8 (VDD), L2.2, L3.2, P2.1, R7.1, R9.1, R10.1, R11.1, R12.1, R17.2, R23.1, R25.1, R26.1, R27.1, R31.1, R34.1, R35.1, R37.1
+1V35: C12.1, C30.2, IC3.8 (VOUT3), P1.14, P1.15, W23.1
+3V3: C10.1, C20.1, C22.1, D7.2 (A), IC3.5 (VOUT1), IC6.19 (VCC), W21.1
+BATT: IC7.3 (SENSE2+), R22.1, R29.2, W11.1
+OSC: C48.1, C49.1, IC5.L14 (FMC_D1/FMC_DA1/TIM4_CH4/UART8_RTS/PD15), IC5.M14 (FMC_D0/FMC_DA0/TIM4_CH3/UART8_CTS/PD14), IC5.M15 (FMC_A18/I2C4_SDA/LPTIM1_OUT/QUADSPI_BK1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), R27.2, X1.4 (VCC)
+SOL: C1.1, D8.1 (K), IC1.1 (VINSNS), IC1.8 (XSHUNT), IC7.1 (SENSE1+), L1.2, R3.1, R18.1, R28.1, W7.1
/ADC_VBAT: IC5.P5 (ADC1_IN15/ADC2_IN15/ETH_RXD1/FMC_SDCKE0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), R5.2, R6.1
/ADC_VSOL: IC5.R2 (ADC1_IN3/ADC2_IN3/ADC3_IN3/ETH_COL/TIM2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), R3.2, R4.1
/ADC_VUSB: IC5.R3 (ADC1_IN7/ADC2_IN7/ETH_CRS_DV/ETH_RX_DV/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), R32.1, R33.2
/BOOT0: IC5.D6 (BOOT0), P5.1, W1.2
/CAM_D2: IC5.H15 (DCMI_D0/I2S2_MCK/SDMMC1_D6/TIM3_CH1/TIM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), P1.6
/CAM_D3: IC5.G15 (DCMI_D1/I2S3_MCK/SDMMC1_D7/TIM3_CH2/TIM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), P1.4
/CAM_D4: IC5.G14 (DCMI_D2/SDMMC1_D0/SYS_TRACED1/TIM3_CH3/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), P1.3
/CAM_D5: IC5.F14 (DAC_EXTI9/DCMI_D3/I2C3_SDA/I2S_CKIN/QUA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), P1.5
/CAM_D6: IC5.B1 (DCMI_D4/FMC_A20/SAI1_FS_A/SPI4_NSS/SYS_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), P1.7
/CAM_D7: IC5.B6 (CAN2_TX/CEC/DCMI_D5/FMC_SDNE1/I2C1_SCL/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), P1.9
/CAM_D8: IC5.B2 (DCMI_D6/FMC_A21/SAI1_SCK_A/SPI4_MISO/SY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), P1.11
/CAM_D9: IC5.B3 (DCMI_D7/FMC_A22/SAI1_SD_A/SAI2_MCLK_B/S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), P1.13
/CAM_EN: IC3.15 (EN3), IC3.16 (EN2), R14.1
/CAM_HREF: IC5.N4 (ADC1_IN4/ADC2_IN4/DAC_OUT1/DCMI_HSYNC/I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), P1.16
/CAM_PCLK: IC5.P3 (ADC1_IN6/ADC2_IN6/DCMI_PIXCLK/SPI1_MISO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), P1.8
/CAM_RESET: IC5.A1 (FMC_A19/SAI1_SD_B/SYS_TRACED0/PE3), P1.19
/CAM_VSYNC: IC5.B5 (DCMI_VSYNC/FMC_NL/I2C1_SDA/TIM4_CH2/USA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), P1.18
/CAM_XCLK: IC5.F15 (I2C3_SCL/RCC_MCO_1/TIM1_CH1/TIM8_BKIN2/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), P1.12
/CLOCK_26M: C16.1, C17.1, C32.1, X1.3 (FREQ)
/CLOCK_CTRL: IC5.P4 (ADC1_IN5/ADC2_IN5/DAC_OUT2/I2S1_CK/SPI1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), R23.2, R24.1, W24.1, X1.1 (AFC)
/GPS_EN: IC3.1 (EN1), IC5.J2 (PF3/ADC3_IN9/FMC_A3), R13.1
/GPS_IRQ: IC5.B14 (DCMI_D8/I2S3_CK/QUADSPI_BK1_IO1/SDMMC1_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), IC6.13 (EXTINT), W20.1
/GPS_RESET: IC5.A11 (FMC_NE1/SPDIFRX_IN0/USART2_CK/PD7), IC6.14 (RESET), W19.1
/GPS_RXD: IC5.D12 (DCMI_D11/SDMMC1_CMD/SYS_TRACED2/TIM3_ET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), IC6.16 (TX_MISO), W15.1
/GPS_TIMEPULSE: IC5.A9 (I2S2_WS/SPI1_MISO/SPI2_NSS/SPI3_MISO/SY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), IC6.31 (TIMEPULSE), R21.2
/GPS_TXD: IC5.A12 (DCMI_D9/I2S3_SD/SDMMC1_CK/SPI3_MOSI/SYS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), IC6.15 (RX_MOSI), W17.1
/I2C_SCL: IC5.A5 (CAN1_RX/DCMI_D6/ETH_TXD3/I2C1_SCL/SDMMC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), IC7.9 (SMCLK), IC8.4 (SCK), P1.20, R19.1, R25.2, W26.1
/I2C_SDA: IC5.B4 (CAN1_TX/DAC_EXTI9/DCMI_D7/I2C1_SDA/I2S2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), IC7.8 (SMDATA), IC8.3 (SDI), P1.22, R20.1, R26.2, W27.1
/IO_LED1: D1.1 (K), IC5.R4 (ADC1_IN9/ADC2_IN9/ETH_RXD3/TIM1_CH3N/TI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), P2.7
/IO_LED2: D2.1 (K), IC5.R5 (ADC1_IN8/ADC2_IN8/ETH_RXD2/TIM1_CH2N/TI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), P2.8
/IO_LED3: D3.1 (K), IC5.P8 (FMC_D5/FMC_DA5/QUADSPI_BK2_IO1/TIM1_CH1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)
/IO_LED4: D4.1 (K), IC5.P11 (FMC_D11/FMC_DA11/SAI2_MCLK_B/SPI4_MOSI/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)
/IO_RXD: IC5.R13 (ADC1_EXTI11/ADC2_EXTI11/ADC3_EXTI11/ETH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), P2.10
/IO_TXD: IC5.R12 (ETH_RX_ER/I2C2_SCL/I2S2_CK/SPI2_SCK/TIM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), P2.9
/PAC_ALERT: IC5.P12 (CAN2_RX/ETH_TXD0/I2C2_SMBA/I2S2_WS/SPI2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), IC7.7 (ALERT)
/RADIO_CS: IC4.15 (CS), IC5.P14 (DAC_EXTI9/FMC_D14/FMC_DA14/USART3_RX/PD9), W12.1
/RADIO_GPIO0: IC4.9 (GPIO0), IC5.N15 (FMC_D15/FMC_DA15/USART3_CK/PD10)
/RADIO_GPIO1: IC4.10 (GPIO1), IC5.P15 (FMC_D13/FMC_DA13/SPDIFRX_IN1/USART3_TX/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)
/RADIO_GPIO2: IC4.19 (GPIO2), R15.2
/RADIO_GPIO3: IC4.20 (GPIO3), R16.2
/RADIO_IRQ: IC4.11 (IRQ), IC5.N14 (ADC1_EXTI11/ADC2_EXTI11/ADC3_EXTI11/FMC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), W18.1
/RADIO_SDN: IC4.1 (SDN), IC5.N13 (FMC_A17/FMC_ALE/I2C4_SCL/LPTIM1_IN1/QUA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), R17.1
/SENSE_BAT-: C3.1, C4.1, C7.1, C8.1, C9.1, IC1.4 (VOUT), IC2.4 (EN), IC2.5 (VIN), IC3.2 (VBIAS), IC3.3 (VIN1/VIN2), IC3.10 (VIN3), IC7.4 (SENSE2-), IC7.10 (VDD), R1.1, R5.1, R22.2, R30.2
/SENSE_SOL-: IC7.2 (SENSE1-), Q1.3 (S), R18.2
/SOL_SHORT_EN: IC5.R9 (FMC_D7/FMC_DA7/QUADSPI_BK2_IO3/TIM1_CH2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), Q1.1 (G), R28.2
/SPI_MISO: IC4.13 (SDO), IC5.R14 (SPI2_MISO/TIM12_CH1/TIM1_CH2N/TIM8_CH2N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), W14.1
/SPI_MOSI: IC4.14 (SDI), IC5.R15 (I2S2_SD/RTC_REFIN/SPI2_MOSI/TIM12_CH2/T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), W13.1
/SPI_SCK: IC4.12 (SCK), IC5.P13 (CAN2_TX/ETH_TXD1/I2S2_CK/SPI2_SCK/TIM1_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), W16.1
/SWD_NRST: IC5.J1 (NRST), P2.5
/SWD_SWCLK: IC5.A14 (SYS_JTCK-SWCLK/PA14), P2.2
/SWD_SWDIO: IC5.A15 (SYS_JTMS-SWDIO/PA13), P2.4
/SWD_SWO: IC5.A10 (I2S1_CK/I2S3_CK/SPI1_SCK/SPI3_SCK/SYS_J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), P2.6
/USB_D+: IC5.B15 (CAN1_TX/SAI2_FS_B/TIM1_ETR/USART1_RTS/U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), P3.3 (D+), R35.2
/USB_D-: IC5.C15 (ADC1_EXTI11/ADC2_EXTI11/ADC3_EXTI11/CAN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), P3.2 (D-)
/USB_ID: IC5.D15 (DCMI_D1/TIM1_CH3/USART1_RX/USB_OTG_FS_I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), P3.4 (ID), R31.2
/V_BOOST: IC5.R6 (PF11/ADC1_EXTI11/ADC2_EXTI11/ADC3_EXTI1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), R36.2
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C18.2, C20.2, C21.2, C22.2, C23.2, C25.2, C27.2, C29.2, C30.1, C31.1, C33.1, C34.1, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.1, D5.1 (K), D6.1 (K), D10.1 (K), D11.1 (K), IC1.2 (GND), IC2.2 (MODE), IC2.6 (GND), IC2.7 (THERM), IC3.12 (GND), IC3.17 (GND), IC4.18 (GND), IC4.21 (THERMAL), IC5.D5 (VSS), IC5.D7 (VSS), IC5.D8 (VSS), IC5.D9 (VSS), IC5.F2 (VSS), IC5.F6 (VSS), IC5.F7 (VSS), IC5.F8 (VSS), IC5.F9 (VSS), IC5.F10 (VSS), IC5.F12 (VSS), IC5.G2 (VSS), IC5.G6 (VSS), IC5.G7 (VSS), IC5.G8 (VSS), IC5.G9 (VSS), IC5.G10 (VSS), IC5.G12 (VSS), IC5.H6 (VSS), IC5.H7 (VSS), IC5.H8 (VSS), IC5.H9 (VSS), IC5.H10 (VSS), IC5.H12 (VSS), IC5.J6 (VSS), IC5.J7 (VSS)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
unnamed: C2.1, IC1.5 (VCTRL), R1.2, R2.1
unnamed: C5.2, IC2.3 (FB), R7.2, R8.1, R36.1
unnamed: C16.2, IC4.17 (XIN)
unnamed: C17.2, IC4.16 (XOUT)
unnamed: C19.1, IC4.4 (TX), L3.1
unnamed: C19.2, L4.2
unnamed: C21.1, C24.1, L4.1, L5.2
unnamed: C24.2, C25.1, C26.1, L5.1, L6.2
unnamed: C26.2, C27.1, L6.1, P4.1
unnamed: C28.1, IC1.6 (ICTRL-), R29.1
unnamed: C28.2, IC1.7 (ICTRL+), R30.1
unnamed: C32.2, IC5.G1 (PH0/RCC_OSC_IN)
unnamed: C35.1, IC5.F13 (VCAP_2)
unnamed: C36.1, IC5.M10 (VCAP_1)
unnamed: C50.2, IC4.2 (RX+), L7.2
unnamed: C51.1, IC4.3 (RX-), L7.1
unnamed: C51.2, W25.1
unnamed: D1.2 (A), R9.2
unnamed: D2.2 (A), R10.2
unnamed: D3.2 (A), R11.2
unnamed: D4.2 (A), R12.2
unnamed: D5.2 (A), R15.1
unnamed: D6.2 (A), R16.1
unnamed: D7.1 (K), R21.1
unnamed: D8.2 (A), D9.1 (K)
unnamed: D9.2 (A), F1.1
unnamed: D10.2 (A), R34.2
unnamed: D11.2 (A), R37.2
unnamed: F1.2, P3.1 (VCC), R33.1
unnamed: IC1.3 (LX), L1.1
unnamed: IC2.1 (SW), L2.1
unnamed: IC6.1 (RF_IN), W3.1
unnamed: IC6.29 (SCL_SCK), R19.2
unnamed: IC6.30 (SDA_CS), R20.2
unnamed: W6.1, W8.1
VDDA: C11.1, C31.2, C33.2, C34.2, IC3.6 (VOUT2), P1.21, W22.1

Board: 4 copper layers, 29.8 x 33.7 mm, 148 parts (35 on the bottom side), 99 nets.

## Code that names these connections

File software/board/board.h (part):

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 */

// IO
#define IO_TXD                      (GPIOB, 10U)
// #define IO_RXD                      (GPIOB, 11U) // used for CAM_EN on Pecan Pico 8a
#define IO_LED1                     (GPIOB, 1U)
#define IO_LED2                     (GPIOB, 0U)
#define IO_LED3                     (GPIOE, 8U)
#define IO_LED4                     (GPIOE, 14U)

// GPS
#define GPS_EN                      (GPIOF, 3U)
#define GPS_TIMEPULSE               (GPIOB, 4U)
#define GPS_RESET                   (GPIOD, 7U)
#define GPS_IRQ                     (GPIOC, 10U)
#define GPS_TXD                     (GPIOC, 12U)
#define GPS_RXD                     (GPIOD, 2U)

// I2C
#define I2C_SCL                     (GPIOB, 8U)
#define I2C_SDA                     (GPIOB, 9U)

// SPI
#define SPI_SCK                     (GPIOB, 13U)
#define SPI_MISO                    (GPIOB, 14U)
#define SPI_MOSI                    (GPIOB, 15U)

// Camera pins
#define CAM_XCLK                    (GPIOA, 8U)
#define CAM_PCLK                    (GPIOA, 6U)
#define CAM_HREF                    (GPIOA, 4U)
#define CAM_VSYNC                   (GPIOB, 7U)
#define CAM_D2                      (GPIOC, 6U)
#define CAM_D3                      (GPIOC, 7U)
#define CAM_D4                      (GPIOC, 8U)
#define CAM_D5                      (GPIOC, 9U)
#define CAM_D6                      (GPIOE, 4U)
#define CAM_D7                      (GPIOB, 6U)
#define CAM_D8                      (GPIOE, 5U)
#define CAM_D9                      (GPIOE, 6U)
#define CAM_EN                      (GPIOB, 11U)
#define CAM_RESET                   (GPIOA, 3U)

// Radio pins
#define RADIO_CS                    (GPIOD, 9U)
#define RADIO_SDN                   (GPIOD, 12U)
#define RADIO_GPIO0                 (GPIOD, 10U)
#define RADIO_GPIO1                 (GPIOD, 8U)
#define RADIO_IRQ                   (GPIOD, 11U)

// ADC
#define ADC_VSOL                    (GPIOA, 3U)
#define ADC_VBAT                    (GPIOC, 5U)
#define ADC_VUSB                    (GPIOA, 7U)

// PAC1720
#define PAC_ALERT                   (GPIOB, 12U)

// USB
#define USB_ID                      (GPIOA, 10U)
#define USB_DM                      (GPIOA, 11U)
#define USB_DP                      (GPIOA, 12U)

// Misc
#define VBOOST                      (GPIOF, 11U)
#define CLOCK_CTRL                  (GPIOA, 5U)
#define OSC_P1                      (GPIOD, 13U)
#define OSC_P2                      (GPIOD, 14U)
#define OSC_P3                      (GPIOD, 15U)
#define SOL_SHORT_EN                (GPIOE, 10U)
#define CLOCK_26M                   (GPIOH, 0U)

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 * PA0  - UART_TX                   (alternate 8)
 * PA1  - UART_RX                   (alternate 8)
 * PA2  - UART_GPS_TX               (alternate 7)
 * PA3  - UART_GPS_RX               (alternate 7)
 * PA4  - CAM_HREF                  (alternate 13)
 * PA5  - PIN5                      (input pullup)
 * PA6  - CAM_PCLK                  (alternate 13)
 * PA7  - RADIO_PWR_REF            (input floating)
 * PA8  - CAM_XCLK                  (alternate 0)
 * PA9  - RADIO_GPIO1              (output pushpull maximum)
 * PA10 - RADIO_GPIO0              (output pushpull maximum)
 * PA11 - RADIO_CS                 (output pushpull maximum)
 * PA12 - RADIO_SDN                (output pushpull maximum)
 * PA13 - SWDIO                     (alternate 0)
 * PA14 - SWCLK                     (alternate 0)
 * PA15 - SD_CS                     (output pushpull maximum)
 */
#define VAL_GPIOA_MODER             (PIN_MODE_INPUT(GPIOA_PIN0) |    \
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/*
 * GPIOB setup:
 *
 * PB0  - RADIO2_CS                 (output pushpull maximum)
 * PB1  - RADIO_PWR_SENSE          (input floating)
 * PB2  - BOOT1                     (input pullup)
 * PB3  - SWO                       (alternate 0)
 * PB4  - PIN4                      (input pullup)
 * PB5  - PIN5                      (input pullup)
 * PB6  - CAM_D7                    (alternate 13)
 * PB7  - CAM_VSYNC                 (alternate 13)
 * PB8  - CAM_SCL                   (alternate 4)
 * PB9  - CAM_SDA                   (alternate 4)
 * PB1  - I2C_SCL                   (alternate 4)
 * PB11 - I2C_SDA                   (alternate 4)
 * PB12 - RADIO2_SDN                (output pushpull maximum)
 * PB13 - SPI_SCK                   (alternate 5)
 * PB14 - SPI_MISO                  (alternate 5)
 * PB15 - SPI_MOSI                  (alternate 5)
 */
#define VAL_GPIOB_MODER             (PIN_MODE_OUTPUT(GPIOB_IO_LED2) |     \
                                     PIN_MODE_OUTPUT(GPIOB_IO_LED1)|\
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 * PC2  - PIN2                      (input pullup)
 * PC3  - PIN3                      (input pullup)
 * PC4  - ADC_VSOLAR                (input pullup)
 * PC5  - ADC_VBAT_DIFF             (input floating)
 * PC6  - CAM_D2                    (alternate 13)
 * PC7  - CAM_D3                    (alternate 13)
 * PC8  - CAM_D4                    (alternate 13)
 * PC9  - CAM_D5                    (alternate 13)
 * PC10 - SD_SCK                    (alternate 6)
 * PC11 - SD_MISO                   (alternate 6)
 * PC12 - SD_MOSI                   (alternate 6)
 * PC13 - LED_2YELLOW                (output pushpull maximum)
 * PC14 - OSC32_IN                  (input floating)
 * PC15 - LED_1RED                   (output pushpull maximum)
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 *
 * PD0  - PIN0                      (input pullup)
 * PD1  - PIN1                      (input pullup)
 * PD2  - PIN2                      (input pullup)
 * PD3  - PIN3                      (input pullup)
 * PD4  - PIN4                      (input pullup)
 * PD5  - PIN5                      (input pullup)
 * PD6  - PIN6                      (input pullup)
 * PD7  - PIN7                      (input pullup)
 * PD8  - PIN8                      (input pullup)
 * PD9  - PIN9                      (input pullup)
 * PD10 - PIN10                     (input pullup)
 * PD11 - PIN11                     (input pullup)
 * PD12 - PIN12                     (input pullup)
 * PD13 - PIN13                     (input pullup)
 * PD14 - PIN14                     (input pullup)
 * PD15 - PIN15                     (input pullup)
 */
#define VAL_GPIOD_MODER             (PIN_MODE_INPUT(GPIOD_PIN0) |           \
                                     PIN_MODE_INPUT(GPIOD_PIN1) |           \
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/*
 * GPIOE setup:
 *
 * PE0  - CAM_EN                   (output pushpull maximum)
 * PE1  - PIN1                      (input pullup)
 * PE2  - PIN2                      (input pullup)
 * PE3  - LED_3GREEN                 (input pullup)
 * PE4  - CAM_D6                    (alternate 13)
 * PE5  - CAM_D8                    (alternate 13)
 * PE6  - CAM_D9                    (alternate 13)
 * PE7  - GPS_EN                    (output pushpull maximum)
 * PE8  - PIN8                      (input pullup)
 * PE9  - PIN9                      (input pullup)
 * PE10 - GPS_TIMEPULSE             (input pullup)
 * PE11 - PIN11                     (input pullup)
 * PE12 - GPS_RESET                 (output pushpull maximum)
 * PE13 - RADIO2_GPIO0              (output pushpull maximum)
 * PE14 - RADIO2_GPIO1              (output pushpull maximum)
 * PE15 - MPU_INT                   (input pullup)
 */
#define VAL_GPIOE_MODER             (PIN_MODE_INPUT(GPIOE_PIN0) |       \
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 * PF0  - PIN0                      (input pullup)
 * PF1  - PIN1                      (input pullup)
 * PF2  - PIN2                      (input pullup)
 * PF3  - PIN3                      (input pullup)
 * PF4  - PIN4                      (input pullup)
 * PF5  - PIN5                      (input pullup)
 * PF6  - PIN6                      (input pullup)
 * PF7  - PIN7                      (input pullup)
 * PF8  - PIN8                      (input pullup)
 * PF9  - PIN9                      (input pullup)
 * PF10 - PIN10                     (input pullup)
 * PF11 - PIN11                     (input pullup)
 * PF12 - PIN12                     (input pullup)
 * PF13 - PIN13                     (input pullup)
 * PF14 - PIN14                     (input pullup)
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/*
 * GPIOH setup:
 *
 * PH0  - PIN0                      (input pullup)
 * PH1  - PIN1                      (input pullup)
 * PH2  - PIN2                      (input pullup)
 * PH3  - PIN3                      (input pullup)
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 * GPIOI setup:
 *
 * PI0  - PIN0                      (input pullup)
 * PI1  - PIN1                      (input pullup)
 * PI2  - PIN2                      (input pullup)
 * PI3  - PIN3                      (input pullup)
 * PI4  - PIN4                      (input pullup)
 * PI5  - PIN5                      (input pullup)
 * PI6  - PIN6                      (input pullup)
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
## Commit log

2016-08-22 Added project files
2016-08-31 Increased via dia, moved drillings in panel
2016-09-04 Moved KiCAD files into hardware folder
2016-09-04 Initialized software
2016-09-04 Added ChibiOS
2016-09-04 Updated Pico8 board configuration
2016-09-04 Adapted code for Pecan Pico 8a, removed buildfiles
2016-09-09 Brought board to work Fixed UART bug Made camera working (hardware fix included) Changed I2C interface
2016-09-15 Adapted code for new Pecan Pico 8a board Changed ADC voltage dividers and channels Adapted PAC1720 channels Changed ublox driver to UART Fixed errors in board configuration Renamed telemetry paramete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
2016-09-16 Done some power saving modifications
2016-10-27 Started developement of rev 8b Changed USB Connector: Mini => Micro Connected CAM_EN to STM32 Added battery jumper switch at programming header Added solar input at programmer header Removed LED outp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
2017-01-16 GPS
    - GPS Antenna went to the backside, so save space.
    - We also use IPEX connectors for the GPS Antenna instead but you can also solder a wire on the connector pad instead.
    Transmitter
    - The space which I won, went into the LPF of the transceiver.
    - We use an LFCN LPF by Mini-Circuits. They are more expensive (~US$5) but work perfectly for us.
    - We also added a RX/TX switch to it. I did this because an Australian friend found out how to receive AFSK APRS with the Si4464.
2017-03-04 Fixed overflow error
2017-03-08 Added new LDO for GPS Implemented constant voltage for LEDs Replaced MicroUSB THT connector with SMD connector Replaced LPF
2017-03-08 Moving parts around
2017-03-09 Moved signals around, created GERBERs
2017-04-03 Replaced inductor for SPV1040, added production information, created GERBERs
2017-04-04 Added solder stop opening below QFN vias Removed copper closer than 0.2mm from the edge of the PCB Created new GERBER files
2017-04-04 Fixed wrong comment
2017-04-14 Revert temporary changes
2017-06-07 Removed unused things Updated logging mechanism (unfinished)
